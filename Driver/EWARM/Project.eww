<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\er-tft040-1-stm32-driver.ewp</path>
  </project>
  <batchBuild />
</workspace>
